## drivers/staging/product_config/Kconfig
```kconfig
config YULONG_PRODUCT
	depends on ARCH_MSM8916
	bool "YULONG_PRODUCT Support"
	default n
	---help---
	  Fix version type as YULONG_PRODUCT
```
